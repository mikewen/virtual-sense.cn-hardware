* EESchema Netlist Version 1.1 (Spice format) creation date: Mon 16 Dec 2013 11:41:30 AM CET

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
P3  ? CONN_1
P2  ? CONN_1
P6  ? CONN_1
P5  ? CONN_1
P7  ? CN
C370  N-000076 N-000062 100pF
C380  N-000067 N-000075 100pF
C371  GND N-000062 1pF
C381  N-000061 N-000067 1pF
C372  GND N-000061 1.8pF
C373  GND N-000059 1.5pF
L370  N-000062 N-000061 1.2nH
L380  GND N-000067 1.2nH
L371  N-000061 N-000059 1.2nH
XU1  GND USB_P USB_N VDD_USB SD_EN/GPIO/PB0 LIGHT_EN/GPIO/PC7 GPIO/PC6 GPIO/PC5 GPIO/PC4 VDD HP-GPIO/PC3 HP-GPIO/PC2 HP-GPIO/PC1 HP-GPIO/PC0 VDD LED0/ROM_BL _RXD/PA0 LED1/ROM_BL _TXD/PA1 LED2/ROM_BL _SEL/PA2 ADC_LIGHT/DIO/GPIO/PA3 CMPN/ADC/DIO/GPIO/PA4 CMPP/ADC/DIO/GPIO/PA5 ADC/DIO/GPIO/PA6 ADC/DIO/GPIO/PA7 VDD GPIO/PD0 GPIO/PD1 SCL/GPIO/PD2 N-000001 SDA/GPIO/PD3 E2PROM_EN/PD4 BAR_EN/PD5 N-000073 VDD XPSC32M_Q1 XPSC32M_Q2 VDD N-000076 N-000075 VDD VDD VDD N-000009 VDD XOSC32K_Q1/PD6 XOSC32K_Q2/PD7 JTAG_TMS JTAG_TCK LIGHT_GC2/JTAG_TDO/PB7 LIGHT_GC1/JTAG_TDI/PB6 RTC_EN/PB5 RTC_INT/PB4 SCK/GPIO/PB3 MOSI/GPIO/PB2 MISO/GPIO/PB1 VDD N-000073 GND CC2538
PCI1  GPIO/PC4 GPIO/PC6 USB_N MOSI/GPIO/PB2 LIGHT_GC1/JTAG_TDI/PB6 JTAG_TCK XOSC32K_Q2/PD7 CLKOUT SDA/GPIO/PD3 RESET_N ? ? ADC/DIO/GPIO/PA6 CMPN/ADC/DIO/GPIO/PA4 LED2/ROM_BL _SEL/PA2 LED0/ROM_BL _RXD/PA0 HP-GPIO/PC1 GND HP-GPIO/PC3 GPIO/PC5 USB_P MISO/GPIO/PB1 SCK/GPIO/PB3 LIGHT_GC2/JTAG_TDO/PB7 JTAG_TMS XOSC32K_Q1/PD6 SCL/GPIO/PD2 ADC/DIO/GPIO/PA7 ? ? CMPP/ADC/DIO/GPIO/PA5 ADC_LIGHT/DIO/GPIO/PA3 LED1/ROM_BL _TXD/PA1 HP-GPIO/PC0 HP-GPIO/PC2 VDD_EB CONN_18X2
P1  VBUS N-000069 N-000068 GND USB-PLUG
CONNA1  HP-GPIO/PC3 GPIO/PC4 GPIO/PC5 GPIO/PC6 LIGHT_EN/GPIO/PC7 SD_EN/GPIO/PB0 USB_P USB_N MISO/GPIO/PB1 MOSI/GPIO/PB2 SCK/GPIO/PB3 LIGHT_GC1/JTAG_TDI/PB6 LIGHT_GC2/JTAG_TDO/PB7 JTAG_TCK JTAG_TMS XOSC32K_Q2/PD7 XOSC32K_Q1/PD6 CLKOUT CONNA
CONNB1  VDD_EB GND HP-GPIO/PC2 HP-GPIO/PC1 HP-GPIO/PC0 LED0/ROM_BL _RXD/PA0 LED1/ROM_BL _TXD/PA1 LED2/ROM_BL _SEL/PA2 ADC_LIGHT/DIO/GPIO/PA3 CMPN/ADC/DIO/GPIO/PA4 CMPP/ADC/DIO/GPIO/PA5 ADC/DIO/GPIO/PA6 ADC/DIO/GPIO/PA7 GPIO/PD0 GPIO/PD1 RESET_N SCL/GPIO/PD2 SDA/GPIO/PD3 CONNB
XU2  VBUS GND GND ? VDD_USB TPS76933
XU8  N-000078 SD_EN/GPIO/PB0 MOSI/GPIO/PB2 VDD SCK/GPIO/PB3 GND MISO/GPIO/PB1 N-000079 MICRO_SD
C10  VBUS GND 1uF
R4  N-000068 USB_P 33
C8  USB_P GND 47pF
C6  USB_N GND 47pF
R1  N-000069 USB_N 33
C14  VDD_USB N-000072 4.7uF
R11  N-000072 GND 2
X1  XPSC32M_Q2 GND XPSC32M_Q1 GND 32MHz
C11  XPSC32M_Q2 GND 22pF
C13  XPSC32M_Q1 GND 22pF
C321  N-000073 GND 1uF
C561  N-000073 GND 1uF
R281  N-000001 RESET_N 2.2K
C281  GND N-000001 1nF
R421  N-000009 GND 56K
X3  N-000081 N-000010 32.768kHz
C5  GND N-000010 18p
C3  GND N-000081 18p
C2  VDD GND 100n
R22  VDD SDA/GPIO/PD3 10K
R21  VDD SCL/GPIO/PD2 10K
XU5  BAR_EN/PD5 N-000055 GND BAR_EN/PD5 BAR_EN/PD5 ? SDA/GPIO/PD3 SCL/GPIO/PD2 MPL115A2
XU7  LIGHT_EN/GPIO/PC7 GND LIGHT_GC1/JTAG_TDI/PB6 LIGHT_GC2/JTAG_TDO/PB7 ADC_LIGHT/DIO/GPIO/PA3 BH1620FVC1
R5  N-000047 GND 47K
R12  ADC_LIGHT/DIO/GPIO/PA3 GND 4.4K
C15  N-000055 GND 1uF
R15  N-000056 GND 400
R14  N-000057 GND 400
R13  N-000058 GND 400
D1  LED1/ROM_BL _TXD/PA1 N-000057 LED
D2  LED2/ROM_BL _SEL/PA2 N-000056 LED
D0  LED0/ROM_BL _RXD/PA0 N-000058 LED
C101  VDD GND 100nF
C151  VDD GND 100nF
C241  VDD GND 100nF
C551  VDD GND 1uF
C331  VDD GND 100nF
C361  VDD GND 100nF
C391  VDD GND 100nF
C392  VDD GND 220pF
C431  VDD GND 100nF
FB1  VDD VDD_EB BLM18HE152SN1
C17  GND VDD 2.2uF
JP1  VDD_USB VDD JUMPER
R20  VDD N-000079 10K
R16  VDD N-000078 10K
XU3  N-000081 ? RTC_INT/PB4 RTC_EN/PB5 GND ? ? MISO/GPIO/PB1 MOSI/GPIO/PB2 SCK/GPIO/PB3 N-000047 CLKOUT VDD ? ? N-000010 GND PCF2123BS
XU6  N-000060 GND VSCN_2_4_F-ANTENNA
R9  N-000059 N-000060 0
R10  N-000059 GND NO
XU4  E2PROM_EN/PD4 E2PROM_EN/PD4 E2PROM_EN/PD4 GND SDA/GPIO/PD3 SCL/GPIO/PD2 GND E2PROM_EN/PD4 GND VSCN-24AA512
P9  N-000065 +
P10  GND -
P4  ? USB_Enclosure
C16  ADC_LIGHT/DIO/GPIO/PA3 GND 47uF
P14  ? DEV-AREA
P13  ? BREAK-LINE
P12  HP-GPIO/PC3 GPIO/PC5 USB_P MISO/GPIO/PB1 SCK/GPIO/PB3 LIGHT_GC2/JTAG_TDO/PB7 JTAG_TMS XOSC32K_Q1/PD6 SCL/GPIO/PD2 ADC/DIO/GPIO/PA7 CONN_10
P11  VDD_EB HP-GPIO/PC2 HP-GPIO/PC0 LED1/ROM_BL _TXD/PA1 ADC_LIGHT/DIO/GPIO/PA3 CMPP/ADC/DIO/GPIO/PA5 CONN_6
P15  GND HP-GPIO/PC1 LED0/ROM_BL _RXD/PA0 LED2/ROM_BL _SEL/PA2 CMPN/ADC/DIO/GPIO/PA4 CONN_5
P16  USB_N MOSI/GPIO/PB2 LIGHT_GC1/JTAG_TDI/PB6 JTAG_TCK XOSC32K_Q2/PD7 CLKOUT SDA/GPIO/PD3 RESET_N CONN_8
R2  VDD VDD_EB 0
R6  N-000040 GND 1.6K
R7  N-000053 N-000052 20K
R3  GND N-000052 10K
R8  N-000051 N-000050 10K
R17  N-000049 N-000065 1K
D3  N-000049 N-000048 LED
XU9  VBUS N-000040 GND N-000053 N-000052 N-000051 N-000050 N-000048 ? N-000065 GND BQ24210

.end
